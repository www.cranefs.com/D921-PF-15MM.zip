# Autodesk Inventor part: D921-PF_15mm
## iProperties
Created: 2011-08
Part Number: D921-PF_15mm
Document SubType Name: Modeling
Designer: D Cole
Density: 1 g/cm^3
Author: D Cole
